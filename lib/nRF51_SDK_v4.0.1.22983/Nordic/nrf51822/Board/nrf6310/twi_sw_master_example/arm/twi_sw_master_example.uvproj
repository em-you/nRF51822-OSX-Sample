# Keil uVision project twi_sw_master_example.uvproj, settings and files
target nRF51822 (ARM-ADS)
  device: nRF51 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: twi_sw_master_example_arm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51 SETUPA
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: main.c
    ../../../../Source/: keil_arm_uv4.lnt
  group core
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../Source/templates/: system_nrf51.c
  group lib
    ../../../../Source/twi_master/: twi_sw_master.c
    ../../../../Source/ext_sensors/ds1624/: ds1624.c
    ../../../../Source/ext_sensors/synaptics_touchpad/: synaptics_touchpad.c
target nRF51822_S110 (ARM-ADS)
  device: nRF51 Nordic
  cpu: as above
  output: twi_sw_master_example_arm_s110 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF51 SETUPA
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2C000
  memory RVCT9: RAM 0x20002000 size 0x2000
