# Keil uVision project ble_app_dtm.uvproj, settings and files
target nRF51822 (ARM-ADS)
  device: nRF51822 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_dtm +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51
  c misc: --c99
  c include: ..\..\..\..\..\Include\ble;..\..\..\..\..\Include
  asm misc: --cpreproc --cpreproc_opts='-DASSEMBLER_PREPROC__'
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --remove
  group Startup Code
    ../../../../../Source/templates/: system_nrf51.c
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
  group Source Code
    ../: main.c
  group Libraries
    ../../../../../Source/ble/: ble_dtm.c
