# Keil uVision project ble_app_gls.uvproj, settings and files
target nRF51822_S110 (ARM-ADS)
  device: nRF51822 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_gls +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice;..\..\..\..\..\Include\ext_sensors
  memory RVCT4: ROM 0x14000 size 0x2C000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_dis.c ble_bas.c ble_gls.c ble_gls_db.c
  group Libraries
    ../../../../../Source/ble/: ble_conn_params.c ble_advdata.c ble_sensorsim.c ble_stack_handler.c ble_racp.c ble_bondmngr.c ble_flash.c ble_radio_notification.c ble_error_log.c ble_debug_assert_handler.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/app_common/: app_timer.c app_button.c app_gpiote.c
    ../../../../../Source/ext_sensors/nRF6350/: nRF6350.c
    ../../../../../Source/twi_master/: twi_hw_master.c
