# Keil uVision project gzp_desktop_mouse_keyboard_emulator_nrf51.uvproj, settings and files
target nRF51822 (ARM-ADS)
  device: nRF51 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: gzll_nrfready_desktop_device_emulator_nrf51 +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51
  c misc: --c99
  c include: ..\;..\..\..\..\..\Include;..\..\..\..\..\Include\gzll;..\..\..\..\..\Include\gzp
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x14000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --info=inline
  group app
    ../: main_mouse_keyboard_emulator_nrf51.c keyboard_emulator.c mouse_sensor_emulator.c
  group system
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../Source/templates/: system_nrf51.c
  group lib
    ../../../../../Lib/gzll/arm/: gzll_arm.lib
  group gzp
    ../../../../../Source/gzp/: nrf_gzp_device.c nrf_gzp.c
    ../../../../../Source/nrf_ecb/: nrf_ecb.c
    ../../../../../Source/nrf_nvmc/: nrf_nvmc.c
target nRF51822_S110 (ARM-ADS)
  device: nRF51 Nordic
  cpu: as above
  output: gzll_nrfready_desktop_device_emulator_nrf51_sd +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51, SOFTDEVICE
  c misc: --c99
  c include: as above
  asm include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2c000
  memory RVCT9: RAM 0x20002000 size 0x2000
  link misc: --info=inline
