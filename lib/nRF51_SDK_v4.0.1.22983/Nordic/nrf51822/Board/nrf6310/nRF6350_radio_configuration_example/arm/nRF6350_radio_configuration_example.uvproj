# Keil uVision project nRF6350_radio_configuration_example.uvproj, settings and files
target nRF51822 (ARM-ADS)
  device: nRF51 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nRF6350_radio_configuration_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 SETUPA
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: main.c
  group core
    ../../../../Source/templates/: system_nrf51.c
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
  group lib
    ../../../../Source/ext_sensors/nRF6350/: nRF6350.c
    ../../../../Source/twi_master/: twi_hw_master.c
target nRF51822_S110 (ARM-ADS)
  device: nRF51 Nordic
  cpu: as above
  output: nRF6350_radio_configuration_example_arm_s110 +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 SETUPA
  c misc: --c99
  c include: ..\..\..\..\Include;..\..\..\..\Include\ext_sensors;..\
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2C000
  memory RVCT9: RAM 0x20002000 size 0x2000
